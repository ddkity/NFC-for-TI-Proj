<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\air_cleaner.ewp</path>
    </project>
    <batchBuild />
</workspace>
