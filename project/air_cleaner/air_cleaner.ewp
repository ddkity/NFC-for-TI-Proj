# IAR project air_cleaner.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\Hardware; ..\..\NFC; ..\..\tag; ..\..\ant; ..\..\comm; ..\Hardware; ..\NFC; ..\tag; ..\comm; ..\ant; ..\des
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group comm
    ../../comm/: comm.c
  group des
    ../../des/: des.c des_enc.c ecb_enc.c set_key.c
  group Hardware
    ../../Hardware/: mcu.c spi.c trf79xxa.c uart.c VLO_Library.s43
  group NFC
    ../../NFC/: felica.c iso14443a.c iso14443b.c iso15693.c ndef.c nfc_app.c
  group tag
    ../../tag/: aes.c bit.c rc4.c simple_cipher.c tag_read.c
  group user
    ./: main.c system_pre_init.c
